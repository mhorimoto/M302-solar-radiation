# Repository mhorimoto/M302-solar-radiation

File README.md:

# M302を用いた日射量計

* Arduino UNO
* M302K
* MSX8725C(marutsu)のSX8725C(A/D Converter)
* 日射計 SOLOR MINI "PCM-01N"

を用いた日射量観測ノード

## Directories

### test

MSX8725を使用するテストプログラムを収めておく。

### main

メインプログラムを収めておく。

## KiCad design KiCAD/M302.kicad_pcb

File KiCAD/README.md:

M302-solar-radiation 日射量観測ノード
======================================================

# 概要

Arduino UNOのシールドとして UECS で農業環境計測で使用しやすい
センサ類の接続に特化した基板。

## 初版 (1.00)

# Interface仕様

 ADCはSX8725Cを用いる。  
 single-endでVref=1.22V
 AC2が正、AC3がGND
 D0 => A0
 D1 => A1
 READY => A2

# プログラム

''git@github.com:mhorimoto/M302-solar-radiation.git''

Board: 2 copper layers, 68.6 x 53.3 mm, 28 parts (0 on the bottom side), 23 nets.

Parts:
C1, C3: 100uF/25V; CP_Radial_D5.0mm_P2.00mm
C2, C4: 0.1μF; C_Disc_D3.0mm_W2.0mm_P2.50mm
J1: I2C-SHT3x; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J2: I2C-ThmCp; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J3: I2C-3; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J4: I2C-4; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J5: I2C-D400; JST_XH_B7B-XH-A_1x07_P2.50mm_Vertical
J6: W5500; PinHeader_2x05_P2.54mm_Vertical
J7: IM920; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J8: PWR+5V; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J9: ANALOG-IN; JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
P1: Power; Socket_Strip_Arduino_1x08
P2: Analog; Socket_Strip_Arduino_1x06
P3: Digital; Socket_Strip_Arduino_1x10
P4: Digital; Socket_Strip_Arduino_1x08
P5, P6, P7, P8: CONN_01X01; Arduino_1pin
R1, R2, R3: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: CPU; TVDT18-050
SW2: D400; TVDT18-050
SW3: IM920; TVDT18-050
U1: SFE-BOB-12009

Connections:
+3V3: C3.1, C4.1, J6.1, J7.4, P1.4, U1.LV
+5V: C1.1, C2.1, J1.2, J2.2, J3.2, J4.2, J5.1, J6.2, J8.1, P1.5, R1.1, R2.1, R3.2, U1.HV
/3(**): J5.6, P4.5, R2.2, SW2.2
/4: P4.4, R3.1, SW3.1, U1.HV4
/5(**): P4.3, U1.HV3
/6(**): P4.2, U1.HV2
/7: P4.1, U1.HV1
/10(**/SS): J6.7, P3.8
/11(**/MOSI): J6.5, P3.7
/12(MISO): J6.3, P3.6
/13(SCK): J6.9, P3.5
/A4(SDA): J1.3, J2.3, J3.3, J4.3, J5.4, P3.2
/A5(SCL): J1.4, J2.4, J3.4, J4.4, J5.7, P3.1
/Reset: J6.6, P1.3, R1.2, SW1.2
GND: C1.2, C2.2, C3.2, C4.2, J1.1, J2.1, J3.1, J4.1, J5.3, J6.4, J7.3, J8.2, J9.2, J9.4, J9.6, J9.8, P1.6, P1.7, P3.4, SW1.1, SW2.1, SW3.2, U1.HGND, U1.LGND
unnamed: J7.1, U1.LV4
unnamed: J7.2, U1.LV3
unnamed: J7.5, U1.LV2
unnamed: J7.6, U1.LV1
unnamed: J9.1, P2.1
unnamed: J9.3, P2.2
unnamed: J9.5, P2.3
unnamed: J9.7, P2.4

## Commit log

2023-06-29 prog: スマ農塾からの離脱コード
2023-06-29 prog: test1
2023-07-04 prog: sx 動き始めるが結果が良いのかわからない
2023-07-06 prog: test2 is LCD available?
2023-07-07 sche: 回路図追記
2023-07-07 prog: EEPROM編集ツール追加
2023-07-08 prog: 実験１のための現地変更
2023-07-08 prog: ADC
2023-07-09 prog: main routineに手を入れ始める
2023-07-10 docs: write EEPROM MAP
2023-07-10 docs: HTML man
2023-07-14 docs
2023-07-14 sys: add html service
2023-07-14 prog: 1st release?
2023-07-20 prog: A-1S-0からA-10S-0へ
2023-07-23 CAD: 不要な回路を削除
